v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 177.5 -20 190 -20 {lab=T2}
N 130 -60 147.5 -60 {lab=control}
N 90 -20 110 -20 {lab=T1}
N 90 13.75 170 13.75 {lab=VDDd}
N 90 33.75 170 33.75 {lab=VSSd}
C {iopin.sym} 90 -20 0 1 {name=p1 lab=T1}
C {iopin.sym} 190 -20 0 0 {name=p2 lab=T2}
C {ipin.sym} 130 -60 0 0 {name=p3 lab=control}
C {noconn.sym} 147.5 -60 0 1 {name=l1}
C {noconn.sym} 110 -20 0 1 {name=l2}
C {noconn.sym} 177.5 -20 0 0 {name=l3}
C {iopin.sym} 90 13.75 0 1 {name=p9 lab=VDDd
}
C {iopin.sym} 90 33.75 0 1 {name=p10 lab=VSSd
}
C {noconn.sym} 170 13.75 0 1 {name=l4}
C {noconn.sym} 170 33.75 0 1 {name=l5}
